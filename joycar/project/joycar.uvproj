# Keil uVision project joycar.uvproj, settings and files
target release (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: joycar
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\libraries\CMSIS\CM3\CoreSupport;..\libraries\STM32F10x_StdPeriph_Driver\inc;..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\user;..\basic_drivers;..\external_drivers\motor;..\external_drivers\holder
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c command.c utility.c
  group basic_drivers
    ../basic_drivers/: usart.c nvic.c rcc.c systick.c
  group motor
    ../external_drivers/motor/: motor.c
  group holder
    ../external_drivers/holder/: holder.c
  group startup
    ../libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group library
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_flash.c
